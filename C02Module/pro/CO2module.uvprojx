# Keil uVision project CO2module.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CO2module +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\driver;..\driver\System;..\driver\System\Interrupt;..\driver\System\TaskManager;..\driver\ToolBox\Buffer;..\driver\ToolBox\Math;..\usr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../driver/: USART.cpp USART.h ADC.cpp ADC.h MHZ14.cpp MHZ14.h ESP8266.cpp ESP8266.h GPIO.cpp GPIO.h Hint.cpp Hint.h Memory.cpp Memory.h
  group app
    ../usr/: main.cpp transmission.cpp transmission.h WIFI_Memory.cpp WIFI_Memory.h
  group system
    ../driver/System/Interrupt/: Interrupt.cpp Interrupt.h
    ../driver/System/: Configuration.h
    ../driver/System/TaskManager/: TaskManager.cpp TaskManager.h
  group Tool
    ../driver/ToolBox/Buffer/: FIFOBuffer.h
    ../driver/ToolBox/Math/: MathTool.h Quaternion.cpp Quaternion.h Vector3.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
